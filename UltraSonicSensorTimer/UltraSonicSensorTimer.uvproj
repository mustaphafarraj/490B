# Keil uVision project UltraSonicSensorTimer.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: UltraSonicSensorTimer
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: startup.s tm4c123gh6pm.h main.c hc-sr04.h hc-sr04.c UART.h UART.c PLL.h Sound.c Sound.h Speaker.c Speaker.h
